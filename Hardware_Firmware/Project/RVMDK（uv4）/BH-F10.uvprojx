# Keil uVision project BH-F10.uvprojx, settings and files
target MPU (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER, ARM_MATH_CM3
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\ds1302;..\..\User\max30102;..\..\Libraries\Lib\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c sys.c
    ../../User/Led/: bsp_led.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/mpu6050/: mpu6050.c
    ../../User/i2c/: bsp_i2c.c
    ../../User/usart/: bsp_usart.c
    ../../User/font/: fonts.c
    ../../User/lcd/: bsp_ili9341_lcd.c
    ../../User/ds1302/: ds1302.c
    ../../User/max30102/: algorithm.c max30102.c
  group DOC
    ../../Doc/: readme.txt
